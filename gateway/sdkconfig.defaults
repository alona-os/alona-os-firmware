## gateway/sdkconfig.defaults
```kconfig
# ESP-IDF >= 5.1 — gateway + ESP-NOW + MQTT
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8192
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
```
